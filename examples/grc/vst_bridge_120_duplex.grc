options:
  parameters:
    author: MagicYang
    description: 120 MS/s TX/RX antenna-coupled +1 MHz tone. RF enabled, peak -10 dBm, RX reference -20 dBm. Stop flowgraph to turn RF off.
    generate_options: qt_gui
    id: vst_bridge_120_duplex
    output_language: python
    title: VST Bridge - 120 MS/s duplex
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 120e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    comment: Large TX writeStream chunks
    value: '262144'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 'Shared LO: TX and RX both 2500 MHz so +1 MHz tone is inside RX +/-60 MHz'
    value: 2.5e9
  states: {}
- name: tx_peak_dbm
  id: variable
  parameters:
    comment: Antenna demo PeakDbm
    value: '-10'
  states: {}
- name: rx_ref_dbm
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: tone_hz
  id: variable
  parameters:
    comment: Baseband offset +1 MHz (RF = 2501 MHz) — inside RX band
    value: 1e6
  states: {}
- name: analog_sig_source_x_0
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: '[0.5*complex(__import__(''math'').cos(2*__import__(''math'').pi*k/120),__import__(''math'').sin(2*__import__(''math'').pi*k/120)) for k in range(120)]*2184'
    repeat: 'True'
    minoutbuf: '1048576'
    comment: Precomputed periodic 1 MHz tone avoids per-sample NCO cost at 120 MS/s.
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    antenna0: RF_OUT
    center_freq0: freq
    comment: TX same CF as RX; RF ON PeakDbm=-10 for antenna-visible tone. Stop FG -> TXSTOP RF off.
    dev_args: resource=RIO0,rf_enabled=true,peak_dbm=-10
    driver: vst
    gain0: tx_peak_dbm
    samp_rate: samp_rate
    settings0: '"rf_enabled=true"'
    type: fc32
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: RF_IN
    center_freq0: freq
    comment: RX same CF 2500 MHz; expect tone near +1 MHz if RF path couples
    dc_removal0: 'False'
    dev_args: resource=RIO0,backend=dma,transport=shm,display_stride=1,display_mode=snapshot,report_rate=true,max_out=65536
    driver: vst
    gain0: rx_ref_dbm
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: '"RX Spectrum CF=2500 MHz (tone @ +1 MHz)"'
    type: complex
    units: '""'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: 1,0,1,1
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: tx_scheduler
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      self.analog_sig_source_x_0.set_min_noutput_items(262144)
      self.analog_sig_source_x_0.set_max_noutput_items(262144)
      self.analog_sig_source_x_0.set_thread_priority(1)
      self.soapy_custom_sink_0.set_min_noutput_items(262144)
      self.soapy_custom_sink_0.set_max_noutput_items(262144)
      self.soapy_custom_sink_0.set_thread_priority(1)
  states: {}

connections:
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', soapy_custom_sink_0, '0']

metadata:
  file_format: 1
